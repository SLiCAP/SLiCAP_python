* /usr/bin/lepton-netlist -g spice-noqsi -o spXNullor.cir spXNullor.sch
* SPICE file generated by spice-noqsi version 20200416
* Send requests or bug reports to jpd@noqsi.com
.subckt nullor out1 out2 in1 in2
E2 out2 1 in1 in2 1
E1 out2 out1 1 out1 1
.ENDS
