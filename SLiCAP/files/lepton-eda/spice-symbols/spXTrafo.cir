* /usr/bin/lepton-netlist -g spice-noqsi -o spXTrafo.cir spXTrafo.sch
* SPICE file generated by spice-noqsi version 20200416
* Send requests or bug reports to jpd@noqsi.com
.subckt spXTrafo outP outN inP inN n=1
V1 1 outN 0
F1 inP inN V1 {-n}
E1 outP 1 inP inN {n}
.ENDS
