* /usr/bin/lepton-netlist -g spice-noqsi -o spXGyrator.cir spXGyrator.sch
* SPICE file generated by spice-noqsi version 20200416
* Send requests or bug reports to jpd@noqsi.com
.subckt spXGyrator outP outN inP inN G=1
G2 inP inN outP outN {G}
G1 outP outN inP inN {G}
.ENDS
