"My first RC network"
* SPICE file generated by spice-noqsi version 20200416
* Send requests or bug reports to jpd@noqsi.com
V1 1 0 V value=0 dc=0 dcvar=0 noise=0
R1 1 out {R}
C1 out 0 {C}
.param R=1k C={1/(2*pi*R*f_c)} f_c=1k
.end
